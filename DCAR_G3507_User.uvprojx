# Keil uVision project DCAR_G3507_User.uvprojx, settings and files
target DCAR_G3507_User (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20200000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: DCAR_G3507_User +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__,DeviceFamily_MSPM0G350X
  c include: .\User;.\User\Inc;.\Source;.\Source\third_party\CMSIS\Core\Include
  asm define: __MSPM0G3507__,DeviceFamily_MSPM0G350X
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group User
    ./User/: user_main.c dcar_api.h ti_msp_dl_config.c ti_msp_dl_config.h
    ./User/Src/: board_buzzer.c board_keys.c board_oled.c board_photo.c board_uart.c digital_gray8.c route_logic.c route_control.c gray_relocalization.c route_log.c gray8.c yabo_gray8_uart.c
    ./User/Inc/: board_buzzer.h board_keys.h board_oled.h board_photo.h board_uart.h digital_gray8.h route_config.h route_logic.h route_control.h gray_relocalization.h route_log.h gray8.h yabo_gray8_uart.h
  group Startup
    ./: startup_mspm0g350x_uvision.s
  group CoreLib
    ./lib/: libdcar_core_keil.lib
  group Driverlib
    ./Source/ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_comp.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_gpamp.c dl_gpio.c dl_i2c.c dl_i2s.c dl_iwdt.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_npu.c dl_opa.c dl_rtc.c dl_rtc_a.c dl_rtc_b.c dl_rtc_common.c dl_scratchpad.c dl_spgss.c dl_spi.c dl_tamperio.c dl_timer.c dl_timera.c dl_timerb.c dl_timerg.c dl_trng.c dl_uart.c dl_unicomm.c dl_unicommi2cc.c dl_unicommi2ct.c dl_unicommspi.c dl_unicommuart.c dl_vref.c dl_wwdt.c
    ./Source/ti/driverlib/m0p/: dl_factoryregion.c dl_interrupt.c
    ./Source/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0c1105_c1106.c dl_sysctl_mspm0c110x.c dl_sysctl_mspm0g1x0x_g3x0x.c dl_sysctl_mspm0g352x.c dl_sysctl_mspm0g511x.c dl_sysctl_mspm0g518x.c dl_sysctl_mspm0gx51x.c dl_sysctl_mspm0h321x.c dl_sysctl_mspm0l111x.c dl_sysctl_mspm0l11xx_l13xx.c dl_sysctl_mspm0l122x_l222x.c dl_sysctl_mspm0l211x_l112x.c
